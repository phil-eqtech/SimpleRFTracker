<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gnuradio_freq_listener</value></param>
<param><key>author</key><value>Flynn</value></param>
<param><key>description</key><value>Lisen to a target frequency, and return the gain of the signal through ZEROMQ</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>Simple RF Tracker</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>868000000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>868e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>2400e6</value></param>
<param><key>min</key><value>400e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sampRate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Gain : </value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Freq : </value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>bandwidth</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>BW : </value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_1</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>sampRate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>SPS : </value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>n</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1024</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>grc_pyblock_send_gain</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

En entree ce bloc recupere un tableau des puissances du signal (IQ) au format "vector"
pour ne retourner que le int de la valeur la plus elevee via le protocole ZMQ
"""

import numpy as np
from gnuradio import gr
import zmq

class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Embedded Python Block',   # will show up in GRC
            in_sig=[(np.float32,1024)],
            out_sig=[]
        )
        self.context = zmq.Context()
        self.socket = self.context.socket(zmq.PUSH)
        self.socket.connect("tcp://127.0.0.1:5050")
        
    def work(self, input_items, output_items):
        """example: multiply with constant"""
        gain = sorted(input_items[0][0], reverse = True)
        self.socket.send_json({"gain":int(gain[0])})
        return True</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>sampRate</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>bandwidth</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>sampRate</value></param>
<param><key>width</key><value>int(bandwidth/8)</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>rtl=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>sampRate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>sampRate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client1</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>callback</key><value>set_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>port</key><value>9092</value></param>
<param><key>variable</key><value>freq</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>9090</value></param>
</block>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>grc_pyblock_send_gain</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>grc_pyblock_send_gain</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
